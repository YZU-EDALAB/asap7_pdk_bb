.include 'model_card.pm'
.include 'fin22/A2O1A1Ixp33_fin22.spf'
.include 'fin22/A2O1A1O1Ixp25_fin22.spf'
.include 'fin22/AND2x1_fin22.spf'
.include 'fin22/AND2x2_fin22.spf'
.include 'fin22/AND2x4_fin22.spf'
.include 'fin22/AND2x6_fin22.spf'
.include 'fin22/AND3x1_fin22.spf'
.include 'fin22/AND3x2_fin22.spf'
.include 'fin22/AND3x4_fin22.spf'
.include 'fin22/AND3x6_fin22.spf'
.include 'fin22/AND4x1_fin22.spf'
.include 'fin22/AND4x2_fin22.spf'
.include 'fin22/AND4x4_fin22.spf'
.include 'fin22/AND4x6_fin22.spf'
.include 'fin22/AND5x1_fin22.spf'
.include 'fin22/AND5x2_fin22.spf'
.include 'fin22/AO21x1_fin22.spf'
.include 'fin22/AO21x2_fin22.spf'
.include 'fin22/AO22x1_fin22.spf'
.include 'fin22/AO22x2_fin22.spf'
.include 'fin22/AO31x1_fin22.spf'
.include 'fin22/AO31x2_fin22.spf'
.include 'fin22/AO32x1_fin22.spf'
.include 'fin22/AO32x2_fin22.spf'
.include 'fin22/AO33x1_fin22.spf'
.include 'fin22/AO33x2_fin22.spf'
.include 'fin22/AO211x2_fin22.spf'
.include 'fin22/AO221x1_fin22.spf'
.include 'fin22/AO221x2_fin22.spf'
.include 'fin22/AO222x1_fin22.spf'
.include 'fin22/AO222x2_fin22.spf'
.include 'fin22/AO322x2_fin22.spf'
.include 'fin22/AO331x1_fin22.spf'
.include 'fin22/AO331x2_fin22.spf'
.include 'fin22/AO332x1_fin22.spf'
.include 'fin22/AO332x2_fin22.spf'
.include 'fin22/AO333x1_fin22.spf'
.include 'fin22/AO333x2_fin22.spf'
.include 'fin22/AOI21x1_fin22.spf'
.include 'fin22/AOI21xp5_fin22.spf'
.include 'fin22/AOI21xp25_fin22.spf'
.include 'fin22/AOI22x1_fin22.spf'
.include 'fin22/AOI22xp5_fin22.spf'
.include 'fin22/AOI22xp25_fin22.spf'
.include 'fin22/AOI31xp25_fin22.spf'
.include 'fin22/AOI31xp5_fin22.spf'
.include 'fin22/AOI32x1_fin22.spf'
.include 'fin22/AOI32xp25_fin22.spf'
.include 'fin22/AOI32xp33_fin22.spf'
.include 'fin22/AOI33x1_fin22.spf'
.include 'fin22/AOI33xp33_fin22.spf'
.include 'fin22/AOI211x1_fin22.spf'
.include 'fin22/AOI211x25_fin22.spf'
.include 'fin22/AOI221x1_fin22.spf'
.include 'fin22/AOI221xp25_fin22.spf'
.include 'fin22/AOI222xp25_fin22.spf'
.include 'fin22/AOI311xp33_fin22.spf'
.include 'fin22/AOI321xp25_fin22.spf'
.include 'fin22/AOI322xp25_fin22.spf'
.include 'fin22/AOI331xp33_fin22.spf'
.include 'fin22/AOI332xp33_fin22.spf'
.include 'fin22/AOI333xp33_fin22.spf'
.include 'fin22/ASYNC_reset_DFFHx1_fin22.spf'
.include 'fin22/ASYNC_set_DFFHx1_fin22.spf'
.include 'fin22/BUFx1_fin22.spf'
.include 'fin22/BUFx2_fin22.spf'
.include 'fin22/BUFx3_fin22.spf'
.include 'fin22/BUFx4_fin22.spf'
.include 'fin22/BUFx4f_fin22.spf'
.include 'fin22/BUFx5_fin22.spf'
.include 'fin22/BUFx6f_fin22.spf'
.include 'fin22/BUFx8_fin22.spf'
.include 'fin22/BUFx10_fin22.spf'
.include 'fin22/BUFx12_fin22.spf'
.include 'fin22/BUFx12f_fin22.spf'
.include 'fin22/BUFx16f_fin22.spf'
.include 'fin22/BUFx24_fin22.spf'
.include 'fin22/BUFxp5_fin22.spf'
.include 'fin22/DFFHQNx1_fin22.spf'
.include 'fin22/DFFHQNx2_fin22.spf'
.include 'fin22/DFFHQNx3_fin22.spf'
.include 'fin22/DFFHQx4_fin22.spf'
.include 'fin22/DFFLQNx1_fin22.spf'
.include 'fin22/DFFLQNx2_fin22.spf'
.include 'fin22/DFFLQNx3_fin22.spf'
.include 'fin22/DFFLQx4_fin22.spf'
.include 'fin22/DHLx1_fin22.spf'
.include 'fin22/DHLx2_fin22.spf'
.include 'fin22/DHLx3_fin22.spf'
.include 'fin22/DLLx1_fin22.spf'
.include 'fin22/DLLx2_fin22.spf'
.include 'fin22/DLLx3_fin22.spf'
.include 'fin22/FILLER_fin22.spf'
.include 'fin22/FAx1_fin22.spf'
.include 'fin22/HAx1_fin22.spf'
.include 'fin22/HAxp5_fin22.spf'
.include 'fin22/HB1xp5_fin22.spf'
.include 'fin22/HB2xp5_fin22.spf'
.include 'fin22/HB3xp5_fin22.spf'
.include 'fin22/HB4xp5_fin22.spf'
.include 'fin22/ICGx1_fin22.spf'
.include 'fin22/ICGx2_fin22.spf'
.include 'fin22/ICGx3_fin22.spf'
.include 'fin22/INVx1_fin22.spf'
.include 'fin22/INVx2_fin22.spf'
.include 'fin22/INVx3_fin22.spf'
.include 'fin22/INVx4_fin22.spf'
.include 'fin22/INVx5_fin22.spf'
.include 'fin22/INVx6_fin22.spf'
.include 'fin22/INVx8_fin22.spf'
.include 'fin22/INVx11_fin22.spf'
.include 'fin22/INVx13_fin22.spf'
.include 'fin22/INVxp5_fin22.spf'
.include 'fin22/MAJIxp5_fin22.spf'
.include 'fin22/MAJx2_fin22.spf'
.include 'fin22/MAJx3_fin22.spf'
.include 'fin22/MUX2x1_fin22.spf'
.include 'fin22/MUX2x2_fin22.spf'
.include 'fin22/NAND2x1_fin22.spf'
.include 'fin22/NAND2x1p5_fin22.spf'
.include 'fin22/NAND2x2_fin22.spf'
.include 'fin22/NAND2xp25_fin22.spf'
.include 'fin22/NAND2xp5_fin22.spf'
.include 'fin22/NAND2xp33_fin22.spf'
.include 'fin22/NAND3x1_fin22.spf'
.include 'fin22/NAND3x2_fin22.spf'
.include 'fin22/NAND3xp33_fin22.spf'
.include 'fin22/NAND4xp25_fin22.spf'
.include 'fin22/NAND4xp75_fin22.spf'
.include 'fin22/NAND4x1_fin22.spf'
.include 'fin22/NAND4x2_fin22.spf'
.include 'fin22/NAND5xp2_fin22.spf'
.include 'fin22/NOR2x1_fin22.spf'
.include 'fin22/NOR2x1p5_fin22.spf'
.include 'fin22/NOR2x2_fin22.spf'
.include 'fin22/NOR2xp25_fin22.spf'
.include 'fin22/NOR2xp5_fin22.spf'
.include 'fin22/NOR2xp33_fin22.spf'
.include 'fin22/NOR3x1_fin22.spf'
.include 'fin22/NOR3x2_fin22.spf'
.include 'fin22/NOR3xp33_fin22.spf'
.include 'fin22/NOR4xp25_fin22.spf'
.include 'fin22/NOR4xp75_fin22.spf'
.include 'fin22/NOR4x1_fin22.spf'
.include 'fin22/NOR4x2_fin22.spf'
.include 'fin22/NOR5xp2_fin22.spf'
.include 'fin22/O2A1O1Ixp33_fin22.spf'
.include 'fin22/O2A1O1Ixp5_fin22.spf'
.include 'fin22/OA21x2_fin22.spf'
.include 'fin22/OA22x2_fin22.spf'
.include 'fin22/OA31x2_fin22.spf'
.include 'fin22/OA33x2_fin22.spf'
.include 'fin22/OA211x1_fin22.spf'
.include 'fin22/OA211x2_fin22.spf'
.include 'fin22/OA221x1_fin22.spf'
.include 'fin22/OA221x2_fin22.spf'
.include 'fin22/OA222x1_fin22.spf'
.include 'fin22/OA222x2_fin22.spf'
.include 'fin22/OA331x1_fin22.spf'
.include 'fin22/OA331x2_fin22.spf'
.include 'fin22/OA332x1_fin22.spf'
.include 'fin22/OA332x2_fin22.spf'
.include 'fin22/OA333x1_fin22.spf'
.include 'fin22/OA333x2_fin22.spf'
.include 'fin22/OAI21x1_fin22.spf'
.include 'fin22/OAI21xp5_fin22.spf'
.include 'fin22/OAI21xp25_fin22.spf'
.include 'fin22/OAI22x1_fin22.spf'
.include 'fin22/OAI22xp5_fin22.spf'
.include 'fin22/OAI22xp25_fin22.spf'
.include 'fin22/OAI31xp5_fin22.spf'
.include 'fin22/OAI31xp25_fin22.spf'
.include 'fin22/OAI32x1_fin22.spf'
.include 'fin22/OAI32xp33_fin22.spf'
.include 'fin22/OAI32xp25_fin22.spf'
.include 'fin22/OAI33x1_fin22.spf'
.include 'fin22/OAI33xp33_fin22.spf'
.include 'fin22/OAI211x1_fin22.spf'
.include 'fin22/OAI211xp25_fin22.spf'
.include 'fin22/OAI221x1_fin22.spf'
.include 'fin22/OAI221xp25_fin22.spf'
.include 'fin22/OAI222xp25_fin22.spf'
.include 'fin22/OAI311xp33_fin22.spf'
.include 'fin22/OAI321xp25_fin22.spf'
.include 'fin22/OAI322xp25_fin22.spf'
.include 'fin22/OAI331xp33_fin22.spf'
.include 'fin22/OAI332xp33_fin22.spf'
.include 'fin22/OAI333xp33_fin22.spf'
.include 'fin22/OR2x1_fin22.spf'
.include 'fin22/OR2x2_fin22.spf'
.include 'fin22/OR2x4_fin22.spf'
.include 'fin22/OR2x6_fin22.spf'
.include 'fin22/OR3x1_fin22.spf'
.include 'fin22/OR3x2_fin22.spf'
.include 'fin22/OR3x4_fin22.spf'
.include 'fin22/OR4x1_fin22.spf'
.include 'fin22/OR4x2_fin22.spf'
.include 'fin22/OR4x4_fin22.spf'
.include 'fin22/OR5x1_fin22.spf'
.include 'fin22/OR5x2_fin22.spf'
.include 'fin22/OR5x4_fin22.spf'
.include 'fin22/SDFHx1_fin22.spf'
.include 'fin22/SDFHx2_fin22.spf'
.include 'fin22/SDFHx3_fin22.spf'
.include 'fin22/SDFHx4_fin22.spf'
.include 'fin22/SDFLx1_fin22.spf'
.include 'fin22/SDFLx2_fin22.spf'
.include 'fin22/SDFLx3_fin22.spf'
.include 'fin22/SDFLx4_fin22.spf'
.include 'fin22/TIEHIx1_fin22.spf'
.include 'fin22/TIELOx1_fin22.spf'
.include 'fin22/XNOR2x1_fin22.spf'
.include 'fin22/XNOR2x2_fin22.spf'
.include 'fin22/XNOR2xp5_fin22.spf'
.include 'fin22/XOR2x1_fin22.spf'
.include 'fin22/XOR2x2_fin22.spf'
.include 'fin22/XOR2xp5_fin22.spf'
